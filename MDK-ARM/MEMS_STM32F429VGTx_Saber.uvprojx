# Keil uVision project MEMS_STM32F429VGTx_Saber.uvprojx, settings and files
target MEMS_STM32F429VGTx_Saber (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: MEMS_STM32F429VGTx_Saber
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\Code;   ..\Code\Device;   ..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Code
    ../Code/: MainEntry.c
  group Device
    ../Code/Device/: Device.c dvc_Led.c
    ./: dvcSaber.c dvcSaber.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c
  group Application/User
    ../Src/: tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c usart.c main.c spi.c gpio.c
software components: CMSIS:CORE 4.3.0
